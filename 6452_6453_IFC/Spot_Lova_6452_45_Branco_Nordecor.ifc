Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Número do projeto
Time: 2024-11-26T21:33:04
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - IU alternativa 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 26 21:33:04 2024 * Host: fuleco * Database: C:\Users\jujus\AppData\Local\Temp\148da848-f578-4417-8c7c-919320f5225b\18f5b010-e8a2-4004-b1c6-c3e77ea0b1f3\ifc * Database version: 5507 * Database creation date: Tue Nov 26 21:33:04 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 26 21:33:04 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 26 21:33:04 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Número do projeto
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 0
